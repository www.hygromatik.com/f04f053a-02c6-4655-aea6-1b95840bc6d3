Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: D:\TechnikSVN\Zeichnungen\25.WA\Ausdehnungsgefäße\WO-50 Dummies\WO-50-00510.IFC
Time: 2026-03-25T12:06:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
